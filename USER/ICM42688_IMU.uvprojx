# Keil uVision project ICM42688_IMU.uvprojx, settings and files
target ICM42688_IMU (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ICM-20602-IMU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,ICM42688P
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\IIC;..\HARDWARE\IMU;..\HARDWARE\EEPROM;..\HARDWARE\SPI;..\HARDWARE\ICM42688
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c example-raw-data-registers.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/IMU/: IMU.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_spi.c
  group Invn
    ../Invn/Drivers/Icm426xx/: Icm426xxDriver_HL.c Icm426xxDriver_HL_apex.c Icm426xxSelfTest.c Icm426xxTransport.c
    ../Invn/EmbUtils/: ErrorHelper.c
software components: CMSIS:CORE 5.0.1
